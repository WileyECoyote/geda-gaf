********************************************************************************
*           Electronic circuit simulation file generated by gSpiceUI           *
*                         Version 1.1.01 (2015-08-10)                          *
********************************************************************************

* Include Directives
.INCLUDE ./models/2N5245.mod
.INCLUDE ./models/bjt.lib

* Component Definitions
C1 +24V 0 100uF
C2 Q2G Q1DQ2S 470pF
C4 +24V Q3SWAMP 100uF
C5 Q4E Vout 33uF
JQ1 Q1DQ2S Vin Q1S J2N5245
JQ2 Q2D Q2G Q1DQ2S J2N5245
Q3 Q3CQ4B Q2D Q3E 2N5087
Q4 Q4CQ5B Q3CQ4B Q4E 2N3866
Q5 Q4E Q4CQ5B +24V 2N5087
R1 Q2G +24V 33k
R10 FBI Q3CQ4B 1.2k
R11 0 FBI 10
R12 0 Q4E 1.65k
R13 0 Vout 600
R2 0 Q2G 6.8K
R3 0 Vin 10Meg
R4 Q2D +24V 1.65k
R5 0 Q1S 120
R8 Q3SWAMP +24V 680
R9 Q3E Q3SWAMP 220
Vpwr +24V 0 DC 24V
* Signal source (Vsignal Vin 0 DC 0 AC 0V SIN(0 1V 10KHZ))
Vsignal Vin 0 SIN( 0.00 250.00m 3.00k 0.00m 0.00 )

* NG-Spice Simulation Commands
.OPTIONS NOPAGE WIDTH=104 UNITS=RADIANS
.PRINT TRAN V(Vin,0) V(Vout) V(Q3CQ4B) V(Q2D)
.TRAN 10.00m 100.00m 0.00m

.END
