* gnetlist -g spice-anise -O include_mode -O sort_mode -O embed_mode -o CascodeAmp.cir /home/wiley/Projects/geda-gaf/examples/CascodeAmp/CascodeAmp.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-anise version 2015.08.08                        *
*********************************************************
.INCLUDE ./models/2N5245.mod
.INCLUDE ./models/bjt.lib
*============== Begin SPICE netlist of main design ============
C1 +24V 0 100uF
C2 Q2G Q1DQ2S 470pF
C4 +24V Q3SWAMP 100uF
C5 Q4E Vout 33uF
JQ1 Q1DQ2S Vin Q1S J2N5245
JQ2 Q2D Q2G Q1DQ2S J2N5245
Q3 Q3CQ4B Q2D Q3E 2N5087
Q4 Q4CQ5B Q3CQ4B Q4E 2N3866
Q5 Q4E Q4CQ5B +24V 2N5087
R1 Q2G +24V 33k
R10 FBI Q3CQ4B 1.2k
R11 0 FBI 10
R12 0 Q4E 1.65k
R13 0 Vout 600
R2 0 Q2G 6.8K
R3 0 Vin 10Meg
R4 Q2D +24V 1.65k
R5 0 Q1S 120
R8 Q3SWAMP +24V 680
R9 Q3E Q3SWAMP 220
Vpwr +24V 0 DC 24V
Vsignal Vin 0 DC 0 AC 0V SIN(0 250V 1KHZ)
*vvvvvvvv  Included SPICE from ./Simulation.cmd vvvvvvvv
.OP
*.AC DEC 20 100Hz 100KHz
*^^^^^^^^  End of included SPICE from ./Simulation.cmd ^^^^^^^^
*
.OPTIONS TEMP=27
.end
